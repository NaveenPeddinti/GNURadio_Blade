options:
  parameters:
    author: tss-naveen
    generate_options: qt_gui
    id: BladeRF_Transmit
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Rx
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 13,6,8,3
    label: Select Rxn Radio (MILITARY)
    label1: STARS V
    label2: CNR 900
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: Rx_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 14,10,1,5
    start: 80e6
    step: 100e3
    stop: 104e6
    value: 80e6
  states: {}
- name: Tx
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 13,1,8,3
    label: Select Txn Radio (MILITARY)
    label0: STARS V
    label1: CNR 900M
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,10,1,5
    start: 50e6
    step: 100e3
    stop: 104e6
    value: 50e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '44100'
    fh: '-1.0'
    max_dev: 1e3
    quad_rate: '88200'
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(Tx)
    num_inputs: '2'
    num_outputs: '3'
    output_index: int(Rx)
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/tss-naveen/Music/Audio.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/tss-naveen/Music/Audio.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 22,0,7,10
    name: Transmitter
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: Rx_freq
    fftsize: '1024'
    gui_hint: 22,11,7,10
    name: Receiver1
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: Rx_freq
    fftsize: '1024'
    gui_hint: 32,11,7,10
    name: Receiver2
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 32,0,7,10
    name: Transmitter1
    type: complex
  states: {}
- name: qtgui_graphicitem_0
  id: qtgui_graphicitem
  parameters:
    file: /home/tss-naveen/Pictures/bg.jpg
    gui_hint: 13,16,8,5
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '11'
    interp: '500'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: ccc
  states: {}

connections:
- [analog_nbfm_tx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_complex_to_float_0, '0', audio_sink_0_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_selector_0, '1']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_selector_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_2, '0', blocks_float_to_complex_0, '0']
- [blocks_selector_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0, '1', rational_resampler_xxx_0_0, '0']
- [blocks_selector_0, '2', blocks_complex_to_float_0, '0']
- [blocks_selector_0, '2', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_tx_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
